# Keil uVision project test3.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MKL25Z64xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.6.0
  cpu: IROM(0x00000000,0x10000) IRAM(0x1FFFF800,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: test3
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x1ffff800 size 0x2000
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.0, RTOS:uC/OS Common 1.0.0, RTOS:uC/OS Kernel 1.0.0
